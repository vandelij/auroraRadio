options:
  parameters:
    author: Jacob van de Lindt
    generate_options: qt_gui
    id: play_saved_radio
    output_language: python
    title: 'Play saved Radio '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: sunriver_radio
    repeat: 'False'
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
