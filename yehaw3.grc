options:
  parameters:
    generate_options: qt_gui
    id: yehaw3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Volume
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate/50
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sunriver_radio
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-center_freq'
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '750000'
    decim: '12'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '700000'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
